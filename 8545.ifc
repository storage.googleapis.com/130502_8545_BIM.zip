Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: 0001
Time: 2018-08-06T23:22:38
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20150220_1215(x64) - Exporter 16.6.0.0 - Alternate UI 16.6.0.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Mon Aug 06 23:22:38 2018 * Host: DESKTOP-JLKK7TQ * Database: C:\Users\vladb\AppData\Local\Temp\{8D759AA1-5450-4FE0-ACE6-D60991B7B9F4}\ifc * Database version: 5507 * Database creation date: Mon Aug 06 23:22:38 2018 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Mon Aug 06 23:22:38 2018 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Mon Aug 06 23:22:38 2018 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, 0001
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 30, 344238; RefLongitude: -71, -3, -35, -194702; RefElevation: 0 mm
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: 0001; Project Status: Project Status

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: 0001; Project Status: Project Status

# IfcBuildingStorey, Level 1
LongName: Level 1; Elevation: 0 mm
Other(Type) - Category: Levels; Family Name: Level
Identity Data(Type) - Type Name: 8mm Head
Constraints - Elevation: 0 mm
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Name: Level 1; Structural: no
Other - Category: Levels; Family: Level: 8mm Head; Family and Type: Level: 8mm Head; Type: Level: 8mm Head; Type Id: Level: 8mm Head
Constraints(Type) - Elevation Base: Project Base Point
Graphics(Type) - Color: 0; Line Pattern: Centre; Line Weight: 1; Symbol: M_Level Head - Circle: M_Level Head - Circle; Symbol at End 1 Default: no; Symbol at End 2 Default: yes

# IfcFlowController: 8545 Bath and shower faucet, 8545:8545 Bath and shower faucet:351784
In: Level 1
Type - PredefinedType: FAUCET; Material: Plastic, Opaque Black, Brass
Type - Dimensions(Type) - NominalDepth: 220.5 mm; NominalHeight: 298 mm; NominalWidth: 237 mm; Projection: 205 mm
Type - General(Type) - Author: Convergo AB; BIMObjectName: 8545; ConvergoRefNr: 0087-1809-0004-FI; ManufacterURL: http://www.oras.com/; ManufacturerName: Oras; NBSDescription: Water supply fittings for baths; NBSReference: 45-35-70/315; ProductInformation: n/a; Revision: n/a; Uniclass2: Pr_40_30_96_07; Uniclass2015Description: Bath manual water supply sets; Uniclass2015Reference: Pr_40_20_87_07; Version: 1; VersionDate: 24/07/2018
Type - Green Building Properties(Type) - EAN Number: 6414150045547; EN Standard: EN 817; LVI Number: 6318520; Noise Class: II (ISO 3822); NRF Number: 4202071; RSK Number: 8553325; Sintef Certificate: Sintef Nr. 0969; VVS Number: 727253104
Type - Identity Data(Type) - Class: Single lever; Group: Bath and shower faucets; Manufacturer: Oras; Market: INT;DNK;EST;FIN;LVA;LTU;NOR;POL;RUS;SWE;UKR; Model: 8545 Bath and shower faucet; Name_en: 8545 Bath and shower faucet; OmniClass Number: 23.45.55.00; OmniClass Title: Sanitary Faucets, Wastes; Product Code: 8545; Product Datasheet: https://www.oras.com/datasheet/8545/en; Product Family: IL BAGNO ALESSI One by Oras; Product URL: https://www.oras.com/en/products/oras/product/8545; Type Name: 8545 Bath and shower faucet
Type - Materials and Finishes(Type) - FaucetMainMaterial: Brass
Type - Mechanical(Type) - Aerator: Aerator; Connection: Covered eccentric unions; Connection Size: G1/2; Dishwasher Valve: Electronic dishwasher valve; Diverter: Pull diverter; Flow Rate At 300kPa: 0.00988811 m3/s; Installation and Maintenance: https://www.oras.com/fileadmin/resources/110214_PDM_945450_C_(945450-01-16).pdf; Installation Type: Wall-mounted; Installation Width: CC 150± 15 mm; Max. Hot Water Supply: 80 kg/K/s3; Pressure Loss With Flow 02ls: 180000 Pa; Pressure Loss With Flow 03ls: 340000 Pa; Shower Parts: Hand shower, shower hose; Spare Parts: https://www.oras.com/en/products/oras/spareparts/SP8545/; Spout Type: Swivel spout
Type - Other(Type) - AccessibilityPerformance: n/a; AssetType: Fixed; Brand: Oras; Category: Bathroom, shower; CodePerformance: n/a; Color: Chrome; Constituents: n/a; DurationUnit: Year; ExpectedLife: n/a; Family Name: 8545; Features: Single lever; Finish: Polished; Grade: n/a; Material: Brass; ModelNumber: n/a; ModelReference: 8545; Name: 8545 Bath and shower faucet; ReplacementCost: n/a; Shape: Sculptured; Size: 237x220x298 mm; SustainabilityPerformance: n/a; WarrantyDescription: https://warranty.oras.com; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: Year; WarrantyGuarantorLabor: n/a; WarrantyGuarantorParts: n/a
Pset_ManufacturerTypeInformation - ModelReference: 8545; Manufacturer: Oras
Pset_DistributionFlowElementCommon - Reference: 8545 Bath and shower faucet
Constraints - DefaultElevation: 900 mm; Host: Level : Level 1; Level: Level: Level 1; Offset: 0 mm
Dimensions - Area: 0.190648 m2; ConnectorDirection: 0; ConnectorDirectionNote: 0-Up II 1-Back II 2-Down; InletConnectionSize: 15 mm; InletDistance: 150 mm; OutletAngle: 0 deg; Volume: 0.0155913 m3
Identity Data - Mark: 20
Mechanical - System Classification: Domestic Hot Water,Domestic Cold Water
Other - AssetIdentifier: n/a; Barcode: n/a; Category: Plumbing Fixtures; Family: 8545: 8545 Bath and shower faucet; Family and Type: 8545: 8545 Bath and shower faucet; InstallationDate: n/a; SerialNumber: n/a; TagNumber: n/a; Type: 8545: 8545 Bath and shower faucet; Type Id: 8545: 8545 Bath and shower faucet; WarrantyStartDate: n/a
Phasing - Phase Created: New Construction
